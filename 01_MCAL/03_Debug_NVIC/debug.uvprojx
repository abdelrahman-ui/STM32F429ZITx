# Keil uVision project debug.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: debug
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SRC_Layer
    ../02_GPIO/: GPIO_program.c
    ../03_NVIC/: NVIC_program.c
    ../00_RCC/: RCC_program.c
  group APP_Layer
    ./: main.c
  group Includ_Layer
    ../03_NVIC/: NVIC_config.h NVIC_interface.h NVIC_private.h STD_TYPE.h BIT_MATH.h
    ../02_GPIO/: GPIO_private.h GPIO_interface.h GPIO_config.h
    ../00_RCC/: RCC_private.h RCC_interface.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
