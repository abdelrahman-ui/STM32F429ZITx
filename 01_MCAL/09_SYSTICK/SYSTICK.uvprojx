# Keil uVision project SYSTICK.uvprojx, settings and files
target SysTick (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SYSTICK
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App_Layer
    ./: main.c
  group SCR_Layer
    ./: RCC_program.c GPIO_program.c STK_program.c
  group LIB_Layer
    ./: BIT_MATH.h STD_TYPE.h
  group Include_Layer
    ./: GPIO_interface.h GPIO_private.h RCC_config.h RCC_interface.h RCC_private.h STK_private.h STK_interface.h STK_config.h GPIO_config.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
